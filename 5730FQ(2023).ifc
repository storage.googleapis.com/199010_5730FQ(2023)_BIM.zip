Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
Time: 2024-01-29T00:36:50
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20200210_1400(x64) - Exporter 20.2.12.1 - Alternate UI 20.2.12.1
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Jan 29 00:36:50 2024 * Host: DESKTOP-13TP49N * Database: C:\Users\andre\AppData\Local\Temp\8f60cd24-d351-4d47-92a9-e92f049f2c17\6842240a-50e2-4123-95bb-a87b8dd7f680\ifc * Database version: 5507 * Database creation date: Mon Jan 29 00:36:50 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Jan 29 00:36:50 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Jan 29 00:36:50 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm
Other - Category: Project Information

# IfcBuilding
Other - Category: Project Information

# IfcBuildingStorey: Level:Level 1, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: Level 1; Family and Type: Level: Level 1; Type: Level: Level 1; Type Id: Level: Level 1
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Level 1

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCE

# IfcFlowController: 5730FQ Oras Care, 5730FQ(2023):5730FQ Oras Care:149671
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - InletConnectionSize: 10 mm; NominalDepth: 253.96 mm; NominalHeight: 183.495 mm; NominalWidth: 53.9562 mm
Type - Electrical - Battery: AA 1.5 V Lithium x 2; Bluetooth: No Bluetooth; Electrical Connection: 9 V; Operating Voltage: 39 V; Protection Class: IP 55
Type - General - Author: BIMStone; BIMObjectName: 5730FQ(2023); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 1; VersionDate: 17/01/2024
Type - Green Building Properties - EAN Number: 6414150105272; EMC Directive: Radio Equipment Directive 2014/53/EU , Low Voltage Directive 2014/35/EU , EMC Directive 2014/30/EU , RoHS Directive 2011/65/EU; EN Standard: EN 817, EN 15091, ETSI EN 301 489-1 V1.9.2 , ETSI EN 300 328 v2.2.2 , EN 61000-6-1:2007 , EN 61000-6-3:2007+A1:2011+AC:2012 , EN 60335-1:2012+A11+A13+A1+A14+A2+A15:2021, Part 19.11.4; Sales Package dimensions (LxWxH): 754 x 334 x 63; URL Declaration of Asbestos: http://static.oras.com/doc/asbestos; URL Declaration of Conformity: http://static.oras.com/DoC/5730FQ; URL Declaration Of Performance (DOP): http://static.oras.com/doc/DoP; URL Declaration of SCIP: http://static.oras.com/doc/SCIP; URL EcoLabel Declaration: http://static.oras.com/doc/EcoLabel; URL EU Packaging Declaration: http://static.oras.com/doc/packaging; URL Materials Declaration: http://www.oras.com/fileadmin/resources/189425_5730FQ_materialsdeclaration.pdf; URL REACH: http://static.oras.com/doc/reach; URL WEEE: http://static.oras.com/WEEE/5730FQ
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/5730FQ; Catalog Drawing URL: http://static.oras.com/catdrw/5730FQ; Dimension Drawing URL: http://static.oras.com/dimdrw/5730FQ; FDV Document URL: http://www.oras.com/datasheet/5730FQ/en/fdv; Group: Sales item; Installation and Maintenance Guide URL: http://static.oras.com/manual/5730FQ; Long Marketing: Hybrid faucet with Laminar Flow aerator. Easy grip temperature lever for good grip and easy adjustment. SMART intelligent sensor with 3 optical lenses for improved performance. Antiscalding protection for Sensor operation. Easy installation due to fast and easy 3S installation system.; Manufacturer: Oras; Mobile Product Information URL: http://mpi.oras.com/5730FQ; Model: 5730FQ Oras Care; Name_en: 5730FQ Oras Care; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 5730FQ; Product Family: null Single-lever;Hybrid;Battery-operated; Product Image URL: http://static.oras.com/image/5730FQ; Product URL: http://static.oras.com/5730FQ; Short Marketing: Care Hybrid series is giving you a whole new modern design to fit into any kitchen. Lever can easily be moved by using the backside of the hand and with our intelligent touchless functions build into same faucet it also supports hygiene operation without any touch needed.; Technical DataSheet URL: http://www.oras.com/datasheet/5730FQ/en; Type Name: 5730FQ Oras Care; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Automatic Flush Frequency: off (off/1-120 h); Automatic Flush Period: 30 s (1-1800 s); Installation Type: Deck mounted; Max Flow Period: 10 s(1 - 1800 s); Operating Distance: 0-30 mm ( 30/90/110/130 mm); Surface treatment: Chrome
Type - Other - Category: Plumbing Fixtures; AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 5730FQ(2023); Features: Kitchen faucet; Finish: Polished; Grade: n/a; ModelNumber: n/a; ModelReference: 5730FQ; Name: 5730FQ Oras Care; ReplacementCost: n/a; Shape: Sculptured; Size: 55x255x185 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - DefaultElevation: 900 mm; Elevation from Level: 0 mm; Host: Level : Level 1; Level: Level: Level 1; Offset from Host: 0 mm
Dimensions - Area: 0.0713033 m2; Volume: 0.00251909 m3
Identity Data - Mark: 61
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Family: 5730FQ(2023): 5730FQ Oras Care; Family and Type: 5730FQ(2023): 5730FQ Oras Care; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 5730FQ(2023): 5730FQ Oras Care; Type Id: 5730FQ(2023): 5730FQ Oras Care; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
